# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: FT32F030K6ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FT32F0XX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030x8,USE_STDPERIPH_DRIVER,USE_FT32F072X8_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,FT32
  c include: ..\;..\..\..\Libraries\CMSIS\Device\FT\FT32F0xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\FT32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\FT32F0xx_CPAL_Driver\inc;..\..\..\Utilities\FT32_EVAL\Common;..\..\..\Utilities\FT32_EVAL\FT32F030xx_EVAL;..\..\..\develop_lib\hardware\st7789;..\..\..\develop_lib\ft_lib\gpio;..\..\..\develop_lib\hardware;..\..\..\develop_lib\middle_api;..\..\..\develop_lib\middle_api\tft_8080;..\..\..\develop_lib\ft_lib;..\..\..\develop_lib;..\..\meeting_machine_pro;..\..\..\develop_lib\ft_lib\i2c;..\..\..\develop_lib\ft_lib\common;..\..\..\develop_lib\ft_lib\timer;..\..\..\develop_lib\middle_api\queue;..\..\..\develop_lib\middle_api\mid_bk953x;..\..\..\develop_lib\ft_lib\usart;..\..\..\develop_lib\middle_api\trace;..\app;..\..\..\develop_lib\hardware\bk953x;..\..\..\develop_lib\ft_lib\timer_pwm;..\..\..\develop_lib\ft_lib\exit;..\..\..\develop_lib\ft_lib\adc;..\..\..\develop_lib\middle_api\pwm;..\..\..\develop_lib\middle_api\ir;..\..\..\develop_lib\middle_api\mid_timer;..\..\..\develop_lib\third_lib;..\..\..\develop_lib\third_lib\app_timer;..\..\..\develop_lib\middle_api\delay;..\..\..\develop_lib\middle_api\adc;..\..\..\develop_lib\middle_api\mid_gpio;..\..\..\develop_lib\ft_lib\flash;..\..\..\develop_lib\middle_api\mid_flash;..\..\..\develop_lib\third_lib\app_scheduler;..\..\..\develop_lib\hardware\ht1621;..\..\..\develop_lib\ft_lib\systick;..\..\..\develop_lib\middle_api\mid_systick;..\..\..\develop_lib\third_lib\crc32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../: system_ft32f0xx.c
    ../../../Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/arm/: startup_ft32f072xb.s
  group app
    ../: main.c ft32f0xx_it.c
    ../app/: bk953x_handler.c adc_button_handler.c ir_tx_handler.c ad22650_handler.c flash_handler.c lcd_display_handler.c
  group StdPeriph_Driver
    ../../../Libraries/FT32F0xx_StdPeriph_Driver/src/: FT32f0xx_adc.c FT32f0xx_crc.c FT32f0xx_crs.c FT32f0xx_dbgmcu.c FT32f0xx_exti.c FT32f0xx_flash.c FT32f0xx_gpio.c FT32f0xx_i2c.c FT32f0xx_iwdg.c FT32f0xx_misc.c FT32f0xx_pwr.c FT32f0xx_rcc.c FT32f0xx_spi.c FT32f0xx_syscfg.c FT32f0xx_tim.c FT32f0xx_usart.c
  group hardware
    ../../../develop_lib/hardware/st7789/: st7789.c
    ../../../develop_lib/hardware/ht1621/: ht1621.c seg_code.c
    ../../../develop_lib/hardware/bk953x/: bk9532.c
  group ft_lib
    ../../../develop_lib/ft_lib/gpio/: ft_gpio.c
    ../../../develop_lib/ft_lib/i2c/: ft_i2c.c
    ../../../develop_lib/ft_lib/timer/: ft_timer.c
    ../../../develop_lib/ft_lib/usart/: ft_usart.c retarget.c
    ../../../develop_lib/ft_lib/timer_pwm/: ft_timer_pwm.c
    ../../../develop_lib/ft_lib/exit/: ft_exit.c
    ../../../develop_lib/ft_lib/adc/: ft_adc.c
    ../../../develop_lib/ft_lib/flash/: ft_flash.c
    ../../../develop_lib/ft_lib/systick/: ft_systick.c
  group middle_api
    ../../../develop_lib/middle_api/tft_8080/: tft_8080.c
    ../../../develop_lib/middle_api/mid_bk953x/: mid_bk953x.c
    ../../../develop_lib/middle_api/trace/: trace.c
    ../../../develop_lib/middle_api/mid_timer/: mid_timer.c
    ../../../develop_lib/middle_api/ir/: ir_tx_encode.c ir_rx_decode.c
    ../../../develop_lib/middle_api/delay/: mid_delay.c
    ../../../develop_lib/middle_api/adc/: mid_adc.c
    ../../../develop_lib/middle_api/mid_gpio/: mid_gpio.c
    ../../../develop_lib/middle_api/mid_flash/: mid_flash.c
    ../../../develop_lib/middle_api/mid_systick/: mid_systick.c
  group third_lib
    ../../../develop_lib/third_lib/app_scheduler/: app_scheduler.c
    ../../../develop_lib/third_lib/crc32/: crc32.c
